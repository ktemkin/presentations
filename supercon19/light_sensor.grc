options:
  parameters:
    generate_options: qt_gui
    id: light_sensor
    output_language: python
    title: Light Sensors
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: greatfet_adc_source_0
  id: greatfet_adc_source
  parameters:
    prelude: ''
    prelude_script: ''
    sample_rate: samp_rate
  states: {}
- name: i2c_register_source_0
  id: i2c_register_source
  parameters:
    address: '0x39'
    data_to_write: '0xac'
    normalize_by: '255'
    prelude: gf.i2c.transmit(0x39, [0x80, 0x03], 0)
    prelude_script: ''
    read_length: '2'
    sample_rate: samp_rate
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '256'
    srate: samp_rate
    type: float
    yunit: V
  states: {state: disabled}

connections:
- [greatfet_adc_source_0, '0', qtgui_sink_x_0, '0']
- [greatfet_adc_source_0, '0', qtgui_time_sink_x_0, '0']
- [i2c_register_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
