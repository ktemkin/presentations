options:
  parameters:
    author: mossmann
    description: Use an LSM6DSM accelerometer connected via GreatFET One as a guitar pickup.
    generate_options: qt_gui
    id: guitar
    output_language: python
    title: Accelerometer Guitar Amplifier
  states: {}

blocks:
- name: post
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '.1'
    stop: '11.1'
    value: '1'
  states: {}
- name: pre
  id: variable_qtgui_range
  parameters:
    comment: These go to eleven.
    orient: Qt.Horizontal
    start: '0'
    step: '.1'
    stop: '11.1'
    value: '.1'
  states: {}
- name: reverb
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '.1'
    stop: '11.1'
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '6621'
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    comment: distortion!
    hi: '1.0'
    lo: '-1.0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: reverb
    delay: '10000'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: pre-gain
    const: pre*10
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: reverb/11
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    comment: post-gain
    const: post/11
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: post/11
    type: float
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    comment: |-
      Remove DC component
      of signal (e.g. gravity)
      and low frequency rumble.
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: i2c_register_source_0
  id: i2c_register_source
  parameters:
    address: '0x6b'
    comment: Sample the accelerometer's Z axis.
    data_to_write: '0x2c'
    normalize_by: '65535'
    prelude: gf.i2c.write(0x6b, [0x10, 0xa0])
    prelude_script: ''
    read_length: '2'
    sample_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate*29/4
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Convert sample rate from
      maximum supported by
      accelerometer to audio
      sample rate of 48 ksps.
    decim: '4'
    interp: '29'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_rail_ff_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', analog_rail_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [dc_blocker_xx_0_0, '0', rational_resampler_xxx_0, '0']
- [i2c_register_source_0, '0', dc_blocker_xx_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
