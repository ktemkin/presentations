options:
  parameters:
    generate_options: qt_gui
    id: color_light_sensor
    output_language: python
    title: TCS34725 test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: i2c_register_source_0
  id: i2c_register_source
  parameters:
    address: '41'
    data_to_write: '0xb4'
    normalize_by: '65535'
    prelude: ''
    prelude_script: /home/ktemkin/Projects/talk-demos/supercon19/color_light_sensor_prelude.py
    read_length: '2'
    sample_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [i2c_register_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
