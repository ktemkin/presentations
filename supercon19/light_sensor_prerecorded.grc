options:
  parameters:
    generate_options: qt_gui
    id: light_sensor
    output_language: python
    title: Light Sensors
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ktemkin/Projects/talk-demos/supercon19/capture_two_lights_1k_float.bin
    repeat: 'True'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    axislabels: 'False'
    bw: '1000'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
    update_time: '0.1'
    wintype: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    plotconst: 'False'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
